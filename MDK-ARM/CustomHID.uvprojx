# Keil uVision project CustomHID.uvprojx, settings and files
target CustomHID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CustomHID
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Inc;                          ../Drivers/STM32F1xx_HAL_Driver/Inc;                          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                          ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                          ../Drivers/CMSIS/Include;                  ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User
    ../Src/: main.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
